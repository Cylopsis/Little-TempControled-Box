# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa156 (6230000::V6.23::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.06.00
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, DEBUG, CPU_MCXA156VLL, RT_USING_LIBC
  c misc: --target=arm-arm-none-eabi
  c include: rt-thread-5.2.1\libcpu\arm\common;rt-thread-5.2.1\components\net\lwip\lwip-2.0.3\src\include\netif;packages\u8g2-official-latest\sys\rt-thread\port;rt-thread-5.2.1\components\utilities\ulog;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\drivers\wlan;packages\vl53l0x-latest\vl53l0x\platform\inc;.;rt-thread-5.2.1\libcpu\arm\cortex-m33;packages\rw007-v2.1.0;rt-thread-5.2.1\components\libc\posix\ipc;rt-thread-5.2.1\components\libc\compilers\common\extension\fcntl\octal;rt-thread-5.2.1\include;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\drivers\include;board\MCUX_Config\board;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\net\lwip\lwip-2.0.3\src\include;rt-thread-5.2.1\components\net\sal\impl;packages\nxp-mcx-cmsis-latest\Core\Include;Libraries\drivers;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\port;rt-thread-5.2.1\components\net\sal\include\socket;packages\ssd1306-latest\inc;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\nxp-mcx-series-latest\MCXA156;packages\vl53l0x-latest\vl53l0x\core\inc;packages\vl53l0x-latest\inc;packages\nxp-mcx-series-latest\MCXA156\drivers;board;board\ports;rt-thread-5.2.1\components\drivers\smp_call;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\libc\posix\io\epoll;rt-thread-5.2.1\components\libc\compilers\common\include;rt-thread-5.2.1\components\net\sal\include\socket\sys_socket;packages\u8g2-official-latest\csrc;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\inc;Libraries\drivers\config;rt-thread-5.2.1\components\libc\posix\io\poll;packages\rw007-v2.1.0\inc;applications\fan;rt-thread-5.2.1\components\net\lwip\port;rt-thread-5.2.1\components\net\netdev\include;packages\nxp-mcx-series-latest\MCXA156\components\codec;rt-thread-5.2.1\components\libc\posix\io\eventfd;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\libc\compilers\common\extension;applications;rt-thread-5.2.1\components\net\sal\include;rt-thread-5.2.1\components\drivers\include;rt-thread-5.2.1\components\drivers\phy;rt-thread-5.2.1\components\drivers\spi;rt-thread-5.2.1\components\finsh
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: .\board\linker_scripts\MCXA156_flash.scf
  group Applications
    applications/: drv_rw007.c main.c
    applications/fan/: YS4028B12H.c YS4028B12H_Demo.c
  group Compiler
    rt-thread-5.2.1/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread-5.2.1/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread-5.2.1/components/drivers/core/: device.c
    rt-thread-5.2.1/components/drivers/hwtimer/: hwtimer.c
    rt-thread-5.2.1/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    rt-thread-5.2.1/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread-5.2.1/components/drivers/misc/: rt_drv_pwm.c
    rt-thread-5.2.1/components/drivers/pin/: dev_pin.c
    rt-thread-5.2.1/components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    rt-thread-5.2.1/components/drivers/serial/: dev_serial.c
    rt-thread-5.2.1/components/drivers/spi/: dev_spi.c dev_spi_core.c
    rt-thread-5.2.1/components/drivers/wlan/: dev_wlan.c dev_wlan_cfg.c dev_wlan_cmd.c dev_wlan_lwip.c dev_wlan_mgnt.c dev_wlan_prot.c dev_wlan_workqueue.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    Libraries/drivers/: drv_i2c.c drv_pin.c drv_pwm.c drv_spi.c drv_uart.c
  group Finsh
    rt-thread-5.2.1/components/finsh/: cmd.c shell.c msh.c msh_parse.c
  group Kernel
    rt-thread-5.2.1/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread-5.2.1/src/klibc/: rt_vsnprintf_std.c kerrno.c kstring.c kstdio.c rt_vsscanf.c
  group libcpu
    rt-thread-5.2.1/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread-5.2.1/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXA156/arm/: startup_MCXA156.s
    packages/nxp-mcx-series-latest/MCXA156/drivers/: fsl_aoi.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_eqdc.c fsl_erm.c fsl_freqme.c fsl_glikey.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_lpadc.c fsl_lpcmp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ostimer.c fsl_pwm.c fsl_reset.c fsl_spc.c fsl_utick.c fsl_vbat.c fsl_waketimer.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXA156/: system_MCXA156.c
  group lwIP
    rt-thread-5.2.1/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread-5.2.1/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread-5.2.1/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread-5.2.1/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread-5.2.1/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread-5.2.1/components/net/lwip/port/: ethernetif.c sys_arch.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread-5.2.1/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread-5.2.1/components/net/sal/impl/: af_inet_lwip.c
    rt-thread-5.2.1/components/net/sal/socket/: net_netdb.c
    rt-thread-5.2.1/components/net/sal/src/: sal_socket.c
  group ssd1306
    packages/ssd1306-latest/src/: ssd1306.c ssd1306_fonts.c
    packages/ssd1306-latest/examples/: ssd1306_tests.c
  group u8g2
    packages/u8g2-official-latest/csrc/: u8g2_cleardisplay.c u8x8_d_gp1294ai.c u8x8_d_uc1638.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1363.c u8x8_capture.c u8x8_fonts.c u8x8_d_s1d15e06.c u8x8_d_ssd1306_2040x16.c u8x8_d_st7586s_ymc240160.c u8g2_kerning.c u8x8_d_ist7920.c u8x8_setup.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8g2_d_setup.c u8x8_d_uc1610.c u8x8_d_max7219.c u8x8_d_ssd1306_72x40.c u8x8_d_stdio.c u8g2_message.c u8x8_d_hd44102.c u8x8_selection_list.c u8x8_d_st7302.c u8x8_d_st7305.c u8g2_fonts.c u8x8_d_uc1701_dogs102.c u8x8_d_ist3020.c u8x8_d_ssd1316.c u8x8_d_st7920.c u8g2_setup.c u8g2_arc.c u8x8_d_il3820_296x128.c u8x8_d_st7511.c u8x8_d_st75256.c u8g2_polygon.c u8x8_string.c u8x8_d_sbn1661.c u8x8_d_ssd1306_48x64.c u8x8_d_uc1601.c u8g2_selection_list.c u8g2_box.c u8x8_d_pcd8544_84x48.c u8x8_message.c u8x8_d_ssd1322.c u8x8_d_st7539.c u8log.c u8x8_u16toa.c u8x8_d_lc7981.c u8x8_d_ssd1320.c u8x8_d_st75161.c u8x8_byte.c u8x8_input_value.c u8x8_d_pcf8814_hx1230.c u8x8_d_ssd1305.c u8x8_d_st7565.c u8x8_d_uc1628.c u8x8_d_ssd1309.c u8x8_d_st7571.c u8g2_line.c u8x8_d_s1d15721.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_st7586s_jlx320160.c u8log_u8g2.c u8x8_d_s1d15300.c u8x8_d_ssd1326.c u8x8_d_uc1604.c u8x8_cad.c u8g2_bitmap.c u8x8_d_ls013b7dh03.c u8x8_d_ssd1306_64x32.c u8x8_d_st75320.c u8g2_d_memory.c u8x8_d_sed1330.c u8x8_gpio.c u8x8_d_ssd1327.c u8x8_d_uc1608.c u8x8_debounce.c u8g2_buffer.c u8x8_d_gp1247ai.c u8x8_d_ssd1306_96x40.c u8x8_d_st7586s_s028hn118a.c u8log_u8x8.c u8x8_d_sh1106_64x32.c u8x8_d_ssd1306_128x32.c u8x8_d_st75160.c u8g2_intersection.c u8x8_d_ch1120.c u8x8_d_ssd1318.c u8x8_d_st7567.c u8x8_8x8.c mui_u8g2.c u8x8_d_sh1106_72x40.c u8x8_d_ssd1312.c u8x8_d_st7588.c u8g2_button.c u8g2_circle.c u8x8_d_uc1611.c u8x8_d_gp1287ai.c u8x8_d_ssd1325.c u8x8_d_st7586s_jlx384160.c u8g2_hvline.c u8x8_d_sh1107.c u8x8_u8toa.c u8x8_d_sh1122.c u8x8_d_t6963.c u8x8_display.c u8x8_d_uc1617.c u8x8_d_ist3088.c u8x8_d_sh1108.c u8x8_d_st7528.c u8g2_font.c u8x8_d_ks0108.c u8x8_d_ssd1317.c u8g2_input_value.c u8x8_d_uc1701_mini12864.c u8x8_d_gu800.c u8x8_d_ssd1315_128x64_noname.c u8x8_d_st7586s_erc240160.c u8g2_ll_hvline.c u8x8_d_pcf8812.c u8x8_d_ssd1329.c u8x8_d_ssd1362.c mui.c u8x8_d_a2printer.c u8x8_d_uc1609.c u8x8_d_ld7032_60x32.c u8x8_d_ssd1306_96x16.c u8x8_d_st7586s_md240128.c
    packages/u8g2-official-latest/sys/rt-thread/examples/: ssd1306_12864_hw_i2c_example.c
    packages/u8g2-official-latest/sys/rt-thread/port/: u8g2_port.c
  group Utilities
    rt-thread-5.2.1/components/utilities/ulog/backend/: console_be.c
    rt-thread-5.2.1/components/utilities/ulog/: ulog.c
  group vl53l0x
    packages/vl53l0x-latest/vl53l0x/core/src/: vl53l0x_api_calibration.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_api.c vl53l0x_api_core.c
    packages/vl53l0x-latest/examples/: vl53l0x_sample_sensor_v1.c
    packages/vl53l0x-latest/vl53l0x/platform/src/: vl53l0x_platform.c
    packages/vl53l0x-latest/src/: vl53l0x_sensor_v1.c
